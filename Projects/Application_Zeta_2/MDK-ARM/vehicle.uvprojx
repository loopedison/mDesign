# Keil uVision project vehicle.uvprojx, settings and files
target vehicle (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: vehicle +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,APPLICATION_OFFSET=0x00008000
  c misc: --C99
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Drivers\BSP\STM32F103\inc;..\Config;..\Init\Inc;..\Modules\inc;..\..\..\Utilities\CPU_ID;..\..\..\Utilities\CRC16;..\..\..\Utilities\XXTEA
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x8000
  memory RVCT9: RAM 0x20002000 size 0x3000
  link misc: --diag_suppress=L6329
  group Readme
    ../Readme/: readme.txt
  group Drivers/CMSIS
    ../Init/Src/: system_stm32f1xx.c
  group Drivers/CMSIS/Lib/ARM
    ../../../Drivers/CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
  group Drivers/STM32F1xx_HAL_Driver
    ../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group Middlewares/USB_Device_Library
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Drivers/Bsp/stm32f103
    ../../../Drivers/BSP/STM32F103/src/: bsp.c bsp_sysLed.c bsp_uart1.c bsp_usben.c bsp_exti.c bsp_adc1.c bsp_tim2.c bsp_tim3.c bsp_i2c1.c bsp_button.c bsp_ledout.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/Init
    ../Init/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Application/Modules
    ../Modules/src/: application.c usbd_cdc.c usbd_cdc_if.c usbd_conf.c usbd_desc.c storage.c superled.c commander.c commander_if.c tsensor.c tcontrol.c thandler.c
  group Utilities/CPU_ID
    ../../../Utilities/CPU_ID/: cpu_id.c
  group Utilities/CRC16
    ../../../Utilities/CRC16/: crc16.c
software components: CMSIS:CORE 4.1.0
